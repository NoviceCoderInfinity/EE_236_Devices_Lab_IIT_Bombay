Use PIN diode as an RF switch
*Anupam Rawat 22b3982

* [N001] -----||------- [N002]----------------DRN142S-------------- [N003] -----||------ [N004] (V_out)
*  |        100 nF        |                  +       -                |       100 nF       |
*  |                      |                                           |                    |
*  |                      |                                        500 ohm                 |
*                         |                                           |                    |
*  +    6V_p           500 ohm                                        |                    |
*  v_in sine              |                                        [N005]                  |
*  -    10MHz             |                                           |                    |
*                         |                                                                |
*  |                      |                                           +                    |
*  |                      |                                         v_bias               50 ohm
*  |                      |                                           -                    |
*  |                      |                                                                |
*  |                      |                                           |                    |           |\
*  ----------------------------------------------------------------------------------------------------| GND
*                                                                                                      |/

.include "../../Handouts/rn142 1.txt"

vin N001 0 sin(0 3 10MEG 0 0)
c1 N002 N001 100n
r1 N002 0 500
d1 N003 N002 DRN142S
r2 N003 N005 500
c2 N004 N003 100n
r3 N004 0 50
Vbias N005 0 dc -5

.tran 1n 0.5u

.control
run

plot v(N004)

.endc
.end
